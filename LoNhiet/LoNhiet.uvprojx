# Keil uVision project LoNhiet.uvprojx, settings and files
target LoNhiet (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC220LC2AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LoNhiet +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS\Include;..\..\NUC220LC2AN;..\MyLib\inc;..\Device\Nuvoton\NUC200Series\Include;..\StdDriver\inc;..\Common;..\Common\Compiler\IAR;..\..\LoNhiet
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: main.c
  group MyLib
    ../MyLib/src/: Temperature_Conversion.c Scheduler.c LED7Segment.c Button_Processing.c Get_ADC_Value.c SystemTick_App.c Scheduler_Cfg.c Fls.c TimeOut.c TimeOut_Cfg.c Fls_Cfg.c Heater_App.c DateTime_Validation.c
  group CMSIS
    ../Device/Nuvoton/NUC200Series/Source/ARM/: startup_NUC200Series.s
    ../Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
  group StdLibrary
    ../StdDriver/src/: adc.c clk.c gpio.c pdma.c retarget.c sys.c timer.c uart.c wdt.c pwm.c
